# Repository openmvpro/OpenMV_Jetson_VisionArchive

File README.md:

2024/9/8

介绍
  本存储库包含了针对 OpenMV 和 Jetson Nano 的视觉代码，涵盖了从 2018 年到 2022 年的多个电赛和项目。主要用于展示和实现计算机视觉任务，包括目标检测、识别和跟踪等功能。

OpenMV 部分
  概述
    OpenMV 部分包含了针对 OpenMV 开发板的代码，主要用于实现以下功能：
      目标检测：通过摄像头识别和跟踪特定对象。
      图像处理：对捕捉到的图像进行处理，如边缘检测和颜色分割。
  使用方法:
    1、硬件准备：
      OpenMV 开发板
      摄像头模块
      相关连接线
    2、软件要求：
      OpenMV IDE：用于编写和上传代码到 OpenMV 开发板。
    3、示例代码：
      在 OpenMV 目录下，每年的子目录包含对应年份的代码示例。请根据需要选择合适的示例进行运行和测试。
  示例
    请参阅 OpenMV/2022 目录下的 example_code.py 文件，了解如何实现基本的目标检测功能。

Jetson Nano 部分
  概述
    Jetson Nano 部分包含了针对 Jetson Nano 开发板的代码，主要用于实现以下功能：
      深度学习推断：使用预训练模型进行目标检测和分类。
      实时图像处理：利用 Jetson Nano 的强大计算能力处理高分辨率视频流。
  使用方法
    1、硬件准备：
      Jetson Nano 开发板
      摄像头模块或其他视频输入设备
      相关连接线和电源
    2、软件要求：
      JetPack SDK：包含必要的库和工具来支持 Jetson Nano 的深度学习和计算机视觉功能。
      Python 3 和相关的库，如 OpenCV 和 TensorFlow。
    3、示例代码：
      在 Jetson_Nano 目录下，每年的子目录包含对应年份的代码示例。请根据需要选择合适的示例进行运行和测试。
  示例
    请参阅 Jetson_Nano/2022 目录下的 object_detection.py 文件，了解如何使用深度学习模型进行实时目标检测。

联系方式
  如有问题或建议，请通过以下方式与我们联系：
    电子邮件：lgh000401@gmail.com
    GitHub Issues：请在 GitHub 上创建 Issue

## EAGLE design OpenMV/OpenMV4-PCB/OpenMV4修改版PCB/OpenMV4-Modify-Version-master/Reference Document/base/base.brd

File OpenMV/OpenMV4-PCB/OpenMV4修改版PCB/OpenMV4-Modify-Version-master/readme.md:

# Open MV 4修改版

- 说明：参考自官方设计，主要修改的内容如下

	- ① PCB层数由4层板改为2层
	- ② TF卡改为了自弹式卡坐
	- ③ 摄像头连接座子改成了和OpenMV3一样的OV7725摄像头模组（感光芯片+镜头）

- 官方开源设计链接：https://github.com/openmv

- EDA设计软件：Altium Designer 20

- PCB视图

Parts:
C1, C4: 1uF; 0603-CAP
C2, C44: 22uF; 0805
C3, C12: 10uF; 0805
C5, C6, C7, C8, C9, C10, C13: 0.1uF; 0603-CAP
C11, C14, C15: 47uF; EIA3216
C40, C41: 12pF; 0603-CAP
C48, C49: 2.2uF; 0603-CAP
D3: SDM2U20SD3-7; SOD-323
H1, H2: MOUNT-PAD-ROUND2.8; 2,8-PAD
JP1, JP2: PINHD-1X8; 1X08
JP3: PINHD-1X6; 1X06
L1, L2: MPZ1608S181ATAH0; 0603
L3: 4.7uH/1.4A; 1007
LED1: LED-TRICOLOR; LED-TRICOLOR-SMD-MF
LED2, LED3: VSMY12850; LED-1206
LOGO1: OSHW_LOGO_FILLX0100-NT; OSHW_FILLX100_NOTEXT
M1, M2: 9774030243R; 9774030151R
Q1: BSS138; SOT23-3
Q2: Si2301BDS; SOT23-3
R1: 10R; 0603-RES
R2, R9: 10K; 0603-RES
R3, R4: 4.7K; 0603-RES
R5: 100K; 0603-RES
R10: 453K; 0603-RES
RN1: 220R; EXBV8V
RN2, RN3: 10K; EXBV8V
U1: STM32H743VIT6; LQFP100
U5: TPS731XX; SOT23-5
U8: PAM2305AABADJ; TSOT25
X1: MF-CON-MICROUSB-RIGHT; MICROUSB-RIGHT
X2: USD-1040310811; 1040310811
X3: DF12-36-DS
X4: S2B-PH-K-S(LF)(SN); JST-PH-2-THM-RA
Y1: 7S-12.000MAHE-T; CRYSTAL-2.5X2.0

Connections:
BOOT0: JP2.2, RN3.3 (1), U1.94 (BOOT0)
DAC: JP1.7, U1.29 (PA5/SPI1_SCK/OTG_HS_ULPI_CK/TIM2_CH1_ET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)
DCMI_CLK: U1.67 (PA8/MCO1/USART1_CK/TIM1_CH1/I2C3_SCL/OT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), X3.12
DCMI_D0: U1.63 (PC6/I2S2_MCK/TIM8_CH1/SDIO_D6/USART6_TX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), X3.31
DCMI_D1: U1.64 (PC7/I2S3_MCK/TIM8_CH2/SDIO_D7/USART6_RX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), X3.29
DCMI_D2: U1.97 (PE0/TIM4_ETR/FSMC_NBL0/DCMI_D2), X3.35
DCMI_D3: U1.98 (PE1/FSMC_NBL1/DCMI_D3), X3.28
DCMI_D4: U1.3 (PE4/TRACED1/FSMC_A20/DCMI_D4), X3.26
DCMI_D5: U1.92 (PB6/I2C1_SCL/TIM4_CH1/CAN2_TX/OTG_FS_IN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), X3.33
DCMI_D6: U1.4 (PE5/FSMC_A21/TIM9_CH1/DCMI_D6), X3.24
DCMI_D7: U1.5 (PE6/FSMC_A22/TIM9_CH2/DCMI_D7), X3.22
DCMI_FSIN: JP2.3, X3.23
DCMI_HSYNC: U1.28 (PA4/SPI1_NSS/SPI3_NSS/USART2_CK/DCMI_HS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), X3.18
DCMI_PCLK: U1.30 (PA6/SPI1_MISO/TIM8_BKIN/TIM13_CH1/DCMI_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), X3.14
DCMI_PWDN: U1.88 (PD7/USART2_CK/FSMC_NE1/FSMC_NCE2), X3.25
DCMI_RST: U1.69 (PA10/USART1_RX/TIM1_CH3/OTG_FS_ID/DCMI_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), X3.21
DCMI_VSYNC: U1.93 (PB7/I2C1_SDA/FSMC_NL/DCMI_VSYNC/USART1_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), X3.16
EXPST: U1.55 (PD8/FSMC_D13/USART3_TX)
FREX: U1.56 (PD9/FSMC_D14/USART3_RX)
FS_DM: U1.70 (PA11/USART1_CTS/CAN1_RX/TIM1_CH4/OTG_FS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), X1.2 (D-)
FS_DP: U1.71 (PA12/USART1_RTS/CAN1_TX/TIM1_ETR/OTG_FS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), X1.3 (D+)
GND: C1.2, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.C (-), C12.1, C13.2, C14.C (-), C15.C (-), C40.1, C41.1, C44.1, C48.2, C49.2, JP2.8, JP3.6, Q1.2 (S), R2.1, R5.1, R9.1, RN3.6 (2), U1.10 (VSS), U1.19 (VSSA), U1.26 (VSS), U1.49 (VSS), U1.74 (VSS), U1.99 (VSS), U5.2 (GND), U8.2 (GND), X1.5 (GND), X2.CD$2 (CD_POL), X2.G$1 (SHD), X2.G$2 (SHD), X2.G$3 (SHD), X2.G$4 (SHD), X2.P$6 (VSS), X3.5, X3.19, X3.27, X4.2 (1), Y1.2, Y1.4
GPIO1: U1.84 (PD3/FSMC_CLK/USART2_CTS)
GPIO2: U1.85 (PD4/FSMC_NOE/USART2_RTS)
GPIO3: U1.82 (PD1FSMC_D3/CAN1_TX)
I2C1_SCL: R3.2, U1.95 (PB8/TIM4_CH3/SDIO_D4/TIM10_CH1/DCMI_D6/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), X3.32
I2C1_SDA: R4.2, U1.96 (PB9/SPI2_NSS/I2S2_WS/TIM4_CH4/TIM11_CH1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), X3.34
I2C2_SCL: JP1.5, U1.46 (PB10/SPI2_SCK/I2S2_CK/I2C2_SCL/USART3_T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)
I2C2_SDA: JP1.6, U1.47 (PB11/I2C2_SDA/USART3_RX/OTG_HS_ULPI_D4/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)
LED_B: RN1.6 (2), U1.17 (PC2/SPI2_MISO/OTG_HS_ULPI_DIR/TH_MII_TX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)
LED_G: RN1.7 (2), U1.16 (PC1/ETH_MDC/ADC123_IN11)
LED_IR: RN1.5 (2), U1.1 (PE2/TRACECLK/FSMC_A23/ETH_MII_TXD3)
LED_R: RN1.8 (2), U1.15 (PC0/OTG_HS_ULPI_STP/ADC123_IN10)
unnamed: C40.2, U1.13 (PH1/OSC_OUT), Y1.3 (2)
unnamed: C41.2, U1.12 (PH0/OSC_IN), Y1.1
unnamed: Q1.1 (G), R2.2, RN1.4 (1)
unnamed: LED1.B (BLU), RN1.3 (1)
unnamed: L2.1, X1.1 (5V)
unnamed: LED1.R (RED), RN1.1
unnamed: LED1.G (GRN), RN1.2 (1)
unnamed: LED3.C, R1.2
unnamed: C7.1, U5.4 (NR)
unnamed: C4.1, C5.1, L1.1, U1.20 (VREF), U1.21 (VDDA)
unnamed: R5.2, R10.1, U8.4 (VOUT/FB)
unnamed: Q1.3 (D), R1.1
unnamed: LED2.C, LED3.A
NRST: C1.1, JP2.1, JP3.4, RN3.4 (1), U1.14 (NRST)
RAW: C44.2, D3.1 (C), Q2.2 (S), U8.1 (VIN), U8.3 (EN)
RSVD1: X3.1
RSVD2: X3.3
RSVD3: X3.7
RSVD4: X3.9
RSVD5: X3.6
RSVD6: X3.8
SDIO_CLK: U1.80 (PC12/UART5_TX/SDIO_CK/DCMI_D9/SPI3_MOSI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), X2.P$5 (CLK)
SDIO_CMD: RN2.8 (2), U1.83 (PD2/TIM3_ETR/UART5_RXSDIO_CMD/DCMI_D11), X2.P$3 (CMD)
SDIO_D0: RN2.7 (2), U1.65 (PC8/TIM8_CH3/SDIO_D0/TIM3_CH3/USART6_CK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), X2.P$7 (DAT0)
SDIO_D1: RN2.6 (2), U1.66 (PC9/I2S_CKIN/MCO2/TIM8_CH4/SDIO_D1/I2C3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), X2.P$8 (DAT1)
SDIO_D2: RN3.8 (2), U1.78 (PC10/SPI3_SCK/I2S3_CK/UART4_TX/SDIO_D2/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), X2.P$1 (DAT2)
SDIO_D3: RN3.7 (2), U1.79 (PC11/UART4_RX/SPI3_MISO/SDIO_D3/DCMI_D4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), X2.P$2 (DAT3/CD)
SD_CD: RN2.5 (2), U1.81 (PD0/FSMC_D2/CAN1_RX), X2.CD$1 (CD)
SPI2_MISO: JP1.2, U1.53 (PB14/SPI2_MISO/TIM1_CH2N/TIM12_CH1/OTG_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)
SPI2_MOSI: JP1.1, U1.54 (PB15/SPI2_MOSI/I2S2_SD/TIM1_CH3N/TIM8_C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)
SPI2_NSS: JP1.4, U1.51 (PB12/SPI2_NSS/I2S2_WS/I2C2_SMBA/USART3_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)
SPI2_SCLK: JP1.3, U1.52 (PB13/SPI2_SCK/I2S2_CK/USART3_CTS/TIM1_C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)
SPI3_MISO: U1.90 (PB4/NJTRST/SPI3_MISO/TIM3_CH1/SPI1_MISO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), X3.15
SPI3_MOSI: U1.91 (PB5/I2C1_SMBA/TIM3_CH2/SPI1_MOSI/SPI3_M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), X3.17
SPI3_SCLK/TRACESWO: JP3.1, U1.89 (PB3/JTDO/TRACESWO/SPI3_SCK/I2S3_CK/TIM2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), X3.13
SPI3_SSEL: U1.77 (PA15/JTDI/SPI3_NSS/I2S3_WS/TIM2_CH1_ETR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), X3.11
SW: L3.1, U8.5 (SW)
SWCLK: JP3.2, U1.76 (PA14/JTCK-SWCLK)
SWDIO: JP3.3, U1.72 (PA13/JTMS-SWDIO)
TIM4_CH1: JP2.6, U1.59 (PD12/FSMC_A17/TIM4_CH1/USART3_RTS)
TIM4_CH2: JP2.5, U1.60 (PD13/FSMC_A18/TIM4_CH2)
TIM4_CH3: JP2.4, U1.61 (PD14/FSMC_D0/TIM4_CH3)
UART2_RX: U1.87 (PD6/FSMC_NWAIT/USART2_RX)
UART2_TX: U1.86 (PD5/FSMC_NWE/USART2_TX)
VBUS: L2.2, Q2.3 (D), U1.68 (PA9/USART1_TX/TIM1_CH2/I2C3_SMBA/DCMI_D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)
VCAP1: C49.1, U1.48 (VCAP)
VCAP2: C48.1, U1.73 (VCAP)
VCC: C2.2, C3.2, C6.1, C8.1, C9.1, C10.1, C11.A (+), C13.1, C14.A (+), C15.A (+), JP1.8, JP3.5, L1.2, L3.2, LED1.A, LED2.A, R3.1, R4.1, R10.2, RN2.1, RN2.2 (1), RN2.3 (1), RN2.4 (1), RN3.1, RN3.2 (1), RN3.5 (2), U1.6 (VBAT), U1.11 (VDD), U1.27 (VDD), U1.50 (VDD), U1.75 (VDD), U1.100 (VDD), U5.1 (IN), U5.3 (EN), X2.P$4 (VDD), X3.2, X3.10, X3.20, X3.30, X3.36
VDDA: C12.2, U5.5 (OUT), X3.4
VIN: D3.2 (A), JP2.7, Q2.1 (G), R9.2, X4.1 (2)

Notes on the sheet:
PC13, PC14, PC15 and PI8 limited to 3mA/2MHz
SD CARD
Y[9:2] for 8-bit YUV or RGB (Y9 MSB, Y2 LSB)
DVDD not connected, using internal regulator
Notes:
IMAGE SENSOR CONNECTOR
STM32F7xx MCU
IR-RGB LEDs
USB & POWER SUPPLY
DEBUG HEADER
I/O HEADERS
No external termination series resistors are required on DP (D+) and DM (D-) pins since the matching impedance is included in the embedded driver.
The output voltage is calculated as below: Vo = 0.6 * (1+R10/R5)

Board: 4 copper layers, 35.6 x 44.5 mm, 60 parts (4 on the bottom side), 70 nets.

Other parts of the board:
U$1: WEEE
U$2: ROHS
U$3: OMV-LOGO
U$4: OMV-LOGO-SMALL
U$6: OMV-LOGO-BIG

## EAGLE design OpenMV/OpenMV4-PCB/OpenMV4修改版PCB/OpenMV4-Modify-Version-master/Reference Document/sensors/OV7725/OV7725.brd

File OpenMV/OpenMV4-PCB/OpenMV4修改版PCB/OpenMV4-Modify-Version-master/Reference Document/sensors/README.md:

# openmv-boards
OpenMV boards, schematics, and layout

Parts:
C1, C4, C5, C6: 0.1uF; 0603-CAP
C2: 22uF; 0805
C3: 4.7uF; 0603-CAP
C12: 47uF; EIA3216
LM1: LENSMOUNT20MM; LENSMOUNT-20MM
R1: 10k; 0603-RES
R2: 4.7R; 0603-RES
U1: OV7725; CSP2-28
U$3: DF12-36-DP

Connections:
AVDD: C3.1, R2.1, U1.A1 (ADVDD), U1.B3 (AVDD)
DCMI_CLK: U1.F3 (XCLK), U$3.12
DCMI_D0: U1.F5 (D2), U$3.31
DCMI_D1: U1.F2 (D3), U$3.29
DCMI_D2: U1.D6 (D4), U$3.35
DCMI_D3: U1.D1 (D5), U$3.28
DCMI_D4: U1.E6 (D6), U$3.26
DCMI_D5: U1.E1 (D7), U$3.33
DCMI_D6: U1.F6 (D8), U$3.24
DCMI_D7: U1.F1 (D9), U$3.22
DCMI_FSIN: R1.2, U1.A4 (FSIN), U$3.23
DCMI_HSYNC: U1.B6 (HSYNC), U$3.18
DCMI_PCLK: U1.E4 (PCLK), U$3.14
DCMI_PWDN: U1.C1 (PWDN), U$3.25
DCMI_RST: U1.A2 (RESET), U$3.21
DCMI_VSYNC: U1.C6 (VSYNC), U$3.16
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C12.C (-), R1.1, U1.B1 (ADGND), U1.B4 (AGND), U1.F4 (DOGND), U$3.5, U$3.19
I2C1_SCL: U1.A5 (SCL), U$3.32
I2C1_SDA: U1.B5 (SDA), U$3.34
unnamed: C5.1, U1.A3 (VREFH)
unnamed: C6.1, U1.B2 (VREFN)
unnamed: C4.1, U1.E3 (DVDD)
RSVD1: U$3.1
RSVD2: U$3.3
RSVD3: U$3.7
RSVD4: U$3.9
RSVD5: U$3.6
RSVD6: U$3.8
SPI3_MISO: U$3.15
SPI3_MOSI: U$3.17
SPI3_SCLK: U$3.13
SPI3_SSEL: U$3.11
VCC: C1.1, C2.1, C12.A (+), U1.E5 (DOVDD), U$3.2, U$3.10, U$3.20, U$3.30, U$3.36
VDDA: R2.2, U$3.4

Notes on the sheet:
IMAGE SENSOR

Board: 4 copper layers, 35.6 x 16.5 mm, 15 parts (3 on the bottom side), 24 nets.

Other parts of the board:
U$1: WEEE
U$2: ROHS
U$4: OMV-LOGO-SMALL

## EAGLE design OpenMV/OpenMV4-PCB/OpenMV4修改版PCB/OpenMV4-Modify-Version-master/Reference Document/sensors/LEPTON/LEPTON.brd

Parts:
C7, C13: 10 uF; 0805
C8, C9, C18: 1 uF; 0402-CAP
C14, C15, C16: 0.1 uF; 0402-CAP
C19: 47uF; EIA3216
CLK: TPTP16R; TP16R
L1: 10uH; 1210
MISO: TPTP16R; TP16R
MOSI: TPTP16R; TP16R
R1, R2: 10K; 0402-RES
SCLK: TPTP16R; TP16R
SSEL: TPTP16R; TP16R
U2: LM3670MF-1.2/NOPB; SOT23-5
U4: ADP150AUJZ-2.8-R7; SOT23-5
U5: 1050281001; CAM-SOCKET
U$3: DF12(3.0)-36DP-0.5V(86); DF12-36-DP

Connections:
1V2: C13.1, C16.1, L1.2, U2.4 (FB), U5.7 (VDDC)
2V8: C9.1, C14.1, C15.1, U4.5 (VOUT), U5.16 (VDDIO), U5.19 (VDD)
DCMI_CLK: CLK.TP, U5.26 (MST_CLK), U$3.12
DCMI_D0: U$3.31
DCMI_D1: U$3.29
DCMI_D2: U$3.35
DCMI_D3: U$3.28
DCMI_D4: U$3.26
DCMI_D5: U$3.33
DCMI_D6: U$3.24
DCMI_D7: U$3.22
DCMI_FSIN: U$3.23
DCMI_HSYNC: U$3.18
DCMI_PCLK: U$3.14
DCMI_PWDN: R2.1, U5.23 (!PWR_DWN), U$3.25
DCMI_RST: C18.1, R1.1, U5.24 (!RESET), U$3.21
DCMI_VSYNC: U5.2 (GPIO3), U$3.16
GND: C7.2, C8.2, C9.2, C13.2, C14.2, C15.2, C16.2, C18.2, C19.C (-), U2.2 (GND), U4.2 (GND), U5.1 (GND), U5.6 (GND), U5.8 (GND), U5.9 (GND), U5.10 (GND), U5.15 (GND), U5.18 (GND), U5.20 (GND), U5.25 (GND), U5.27 (GND), U5.30 (GND), U5.P$1 (GND), U5.P$2 (GND), U5.P$3 (GND), U5.P$4 (GND), U5.P$5 (GND), U5.P$6 (GND), U5.P$7 (GND), U5.P$8 (GND), U5.P$9 (GND), U5.P$10 (GND), U5.P$11 (GND), U5.P$12 (GND), U5.P$13 (GND), U5.P$14 (GND), U5.P$15 (GND), U5.P$16 (GND), U5.P$17 (GND), U5.P$18 (GND), U5.P$19 (GND), U5.P$20 (GND), U5.P$21 (GND), U5.P$22 (GND), U5.P$23 (GND), U5.P$24 (GND), U5.P$25 (GND), U5.P$26 (GND), U5.P$27 (GND), U5.P$28 (GND), U5.P$29 (GND), U5.P$30 (GND), U5.P$31 (GND), U5.P$32 (GND), U5.P$33 (GND), U5.P$34 (GND), U5.P$35 (GND), U5.P$36 (GND), U$3.5, U$3.19, U$3.27
GPIO0: U5.5 (GPIO0)
GPIO1: U5.4 (GPIO1)
GPIO2: U5.3 (GPIO2)
I2C1_SCL: U5.21 (SCL), U$3.32
I2C1_SDA: U5.22 (SDA), U$3.34
MIPI_CLK_N: U5.28 (!MIPI_CLK)
MIPI_CLK_P: U5.29 (MIPI_CLK)
MIPI_DATA_N: U5.31 (!MIPI_DATA)
MIPI_DATA_P: U5.32 (MIPI_DATA)
unnamed: L1.1, U2.5 (SW)
RSVD1: U$3.1
RSVD2: U$3.3
RSVD3: U$3.7
RSVD4: U$3.9
RSVD5: U$3.6
RSVD6: U$3.8
SPI3_MISO: MISO.TP, U5.12 (SPI_MISO), U$3.15
SPI3_MOSI: MOSI.TP, U5.11 (SPI_MOSI), U$3.17
SPI3_SCLK: SCLK.TP, U5.13 (SPI_CLK), U$3.13
SPI3_SSEL: SSEL.TP, U5.14 (SPI_CSL), U$3.11
VCC: C7.1, C8.1, C19.A (+), R1.2, R2.2, U2.1 (VIN), U2.3 (EN), U4.1 (VIN), U4.3 (EN), U$3.2, U$3.10, U$3.20, U$3.30, U$3.36
VDDA: U$3.4

Board: 4 copper layers, 35.6 x 16.5 mm, 23 parts (9 on the bottom side), 15 nets.

Other parts of the board:
U$4: WEEE
U$5: ROHS

## EAGLE design OpenMV/OpenMV4-PCB/OpenMV4修改版PCB/OpenMV4-Modify-Version-master/Reference Document/sensors/MT9V034/MT9V034.brd

Parts:
C1, C2, C4, C6: 0.1uF; 0402-CAP
C3, C5: 22uF; 0805
L1: MPZ1608S181ATAH0; 0603
LM1: LENSMOUNT20MM; LENSMOUNT-20MM
RN1: 10K; EXBV8V
U1: MT9V034; CLCC-48
U$3: DF12-36-DP

Connections:
DCMI_CLK: U1.P$47 (SYSCLK), U$3.12
DCMI_D0: U1.P$45 (D0), U$3.9
DCMI_D1: U1.P$44 (D1), U$3.7
DCMI_D2: U1.P$43 (D2), U$3.31
DCMI_D3: U1.P$42 (D3), U$3.29
DCMI_D4: U1.P$41 (D4), U$3.35
DCMI_D5: U1.P$15 (D5), U$3.28
DCMI_D6: U1.P$16 (D6), U$3.26
DCMI_D7: U1.P$17 (D7), U$3.33
DCMI_D8: U1.P$18 (D8), U$3.24
DCMI_D9: U1.P$19 (D9), U$3.22
DCMI_FSIN: U$3.23
DCMI_HSYNC: U1.P$20 (LINE_VALID), U$3.18
DCMI_PCLK: U1.P$46 (PIXCLK), U$3.14
DCMI_PWDN: RN1.6 (2), U1.P$33 (STANDBY), U$3.25
DCMI_RST: RN1.7 (2), U1.P$32 (RESET), U$3.21
DCMI_SCL: U1.P$25 (SCLK), U$3.32
DCMI_SDA: U1.P$24 (SDATA), U$3.34
DCMI_VSYNC: U1.P$21 (FRAME_VALID), U$3.16
GND: C1.2, C2.2, C3.1, C4.2, C5.1, C6.2, RN1.3 (1), U1.P$7 (LVDSGND), U1.P$12 (LVDSGND), U1.P$13 (DGND), U1.P$29 (RSVD), U1.P$34 (AGND), U1.P$38 (AGND), U1.P$48 (DGND), U$3.5, U$3.19, U$3.27
unnamed: RN1.5 (2), U1.P$30 (S_CTRL_ADR0)
unnamed: RN1.8 (2), U1.P$31 (S_CTRL_ADR1)
RSVD1: U$3.1
RSVD2: U$3.3
RSVD5: U$3.6
RSVD6: U$3.8
SPI3_MISO: U1.P$23 (EXPOSURE), U$3.15
SPI3_MOSI: U1.P$22 (STLN_OUT), U$3.17
SPI3_SCLK: U1.P$26 (STFRM_OUT), U$3.13
SPI3_SSEL: U1.P$27 (LED_OUT), U$3.11
VAA: C4.1, C5.2, C6.1, L1.2, U1.P$35 (VAA), U1.P$39 (VAA), U1.P$40 (VAAPIX)
VCC: C1.1, C2.1, C3.2, RN1.1, RN1.2 (1), RN1.4 (1), U1.P$1 (VDD), U1.P$6 (VDDLVDS), U1.P$14 (VDD), U1.P$28 (OE), U$3.2, U$3.10, U$3.20, U$3.30, U$3.36
VDDA: L1.1, U$3.4

Board: 4 copper layers, 35.6 x 16.5 mm, 13 parts (11 on the bottom side), 28 nets.

Other parts of the board:
U$1: WEEE
U$2: ROHS

## Commit log

2024-09-08 Add OpenMV and Jetson Nano vision code (2018-2022 projects)
    Projects: Contains vision-related code used in various electronics competitions (2018-2022) and personal projects.
    Hardware: Includes code for OpenMV and Jetson Nano platforms, focusing on computer vision applications such as object detection and image processing.
    Purpose: Initial commit to archive and maintain a history of the vision code from previous competitions and experiments.

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
sfe: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
